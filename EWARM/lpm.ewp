# IAR project lpm.ewp, settings and files
configuration sleep_mode (ARM, debug)
  General.OGChipSelectEditMenu: STM32L486RG ST STM32L486RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L486xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\STM32L4xx_Nucleo; ..\Utilities\tiny_lpm; ..\Utilities\sequencer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lpm.hex
  ILINK.IlinkOutputFile: App.out
  ILINK.IlinkIcfFile: stm32l486xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration stop_mode (ARM, debug)
  as the first configuration, except:
  group Application/EWARM
    ./: startup_stm32l486xx.s
  group Application/User
    ../Src/: main_sleep.c main_stop.c stm32_lpm_if.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/BSP
    ../Drivers/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c
  group Utils
    ../Utilities/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
